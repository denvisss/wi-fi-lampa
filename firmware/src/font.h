#pragma once
#include <FastLED.h>
#include "mapping.h"

// 5x7 шрифт, колонки; bit0 = верхняя строка
namespace font5x7 {

struct Glyph {
  char c;
  uint8_t col[5];
};

static const Glyph GLYPHS[] = {
    {'0', {0x3E, 0x51, 0x49, 0x45, 0x3E}},
    {'1', {0x00, 0x42, 0x7F, 0x40, 0x00}},
    {'2', {0x42, 0x61, 0x51, 0x49, 0x46}},
    {'3', {0x21, 0x41, 0x45, 0x4B, 0x31}},
    {'4', {0x18, 0x14, 0x12, 0x7F, 0x10}},
    {'5', {0x27, 0x45, 0x45, 0x45, 0x39}},
    {'6', {0x3C, 0x4A, 0x49, 0x49, 0x30}},
    {'7', {0x01, 0x71, 0x09, 0x05, 0x03}},
    {'8', {0x36, 0x49, 0x49, 0x49, 0x36}},
    {'9', {0x06, 0x49, 0x49, 0x29, 0x1E}},
    {':', {0x00, 0x24, 0x24, 0x24, 0x00}},
    {'.', {0x00, 0x60, 0x60, 0x00, 0x00}},
    {'-', {0x08, 0x08, 0x08, 0x08, 0x08}},
    {'!', {0x00, 0x00, 0x5F, 0x00, 0x00}},
    {' ', {0x00, 0x00, 0x00, 0x00, 0x00}},
    {'A', {0x7C, 0x12, 0x11, 0x12, 0x7C}},
    {'B', {0x7F, 0x49, 0x49, 0x49, 0x36}},
    {'C', {0x3E, 0x41, 0x41, 0x41, 0x22}},
    {'D', {0x7F, 0x41, 0x41, 0x22, 0x1C}},
    {'E', {0x7F, 0x49, 0x49, 0x49, 0x41}},
    {'F', {0x7F, 0x09, 0x09, 0x01, 0x01}},
    {'H', {0x7F, 0x08, 0x08, 0x08, 0x7F}},
    {'I', {0x00, 0x41, 0x7F, 0x41, 0x00}},
    {'M', {0x7F, 0x02, 0x0C, 0x02, 0x7F}},
    {'N', {0x7F, 0x04, 0x08, 0x10, 0x7F}},
    {'O', {0x3E, 0x41, 0x41, 0x41, 0x3E}},
    {'P', {0x7F, 0x09, 0x09, 0x09, 0x06}},
    {'R', {0x7F, 0x09, 0x19, 0x29, 0x46}},
    {'S', {0x46, 0x49, 0x49, 0x49, 0x31}},
    {'T', {0x01, 0x01, 0x7F, 0x01, 0x01}},
    // Кириллица (упрощённая, для бегущей строки)
    {0xC0 /*А*/, {0x7C, 0x12, 0x11, 0x12, 0x7C}},
    {0xC1 /*Б*/, {0x7F, 0x49, 0x49, 0x49, 0x31}},
    {0xC2 /*В*/, {0x7F, 0x49, 0x49, 0x49, 0x36}},
    {0xC3 /*Г*/, {0x7F, 0x01, 0x01, 0x01, 0x01}},
    {0xC4 /*Д*/, {0x70, 0x1E, 0x11, 0x1F, 0x70}},
    {0xC5 /*Е*/, {0x7F, 0x49, 0x49, 0x49, 0x41}},
    {0xC9 /*Й*/, {0x7F, 0x05, 0x08, 0x11, 0x7F}},
    {0xCC /*М*/, {0x7F, 0x02, 0x0C, 0x02, 0x7F}},
    {0xCD /*Н*/, {0x7F, 0x08, 0x08, 0x08, 0x7F}},
    {0xCE /*О*/, {0x3E, 0x41, 0x41, 0x41, 0x3E}},
    {0xCF /*П*/, {0x7F, 0x01, 0x01, 0x01, 0x7F}},
    {0xD0 /*Р*/, {0x7F, 0x09, 0x09, 0x09, 0x06}},
    {0xD1 /*С*/, {0x3E, 0x41, 0x41, 0x41, 0x22}},
    {0xD2 /*Т*/, {0x01, 0x01, 0x7F, 0x01, 0x01}},
    {0xD7 /*Ч*/, {0x0F, 0x08, 0x08, 0x08, 0x7F}},
    {0xDB /*Ы*/, {0x7F, 0x40, 0x38, 0x40, 0x7F}},
};

inline const uint8_t* glyph(char c) {
  for (const Glyph& gl : GLYPHS) {
    if (gl.c == c) return gl.col;
  }
  return GLYPHS[14].col;  // пробел
}

// Бегущая строка по кольцу: для каждого пикселя кольца берём точку символа.
// scrollPx растёт со временем, строка уезжает влево и зацикливается.
// scale = 1 — кегль 5×7, scale = 2 — 10×14 (символы вдвое крупнее).
// flip = true — поворот изображения на 180°: при калибровке эффектов под
// перевёрнутую ленту текст без этого читается вверх ногами.
inline void drawScrollText(CRGB* fb, const char* text, float scrollPx, const CRGB& color,
                           bool rainbow, float t, uint8_t scale = 1, bool flip = false) {
  int len = strlen(text);
  if (len <= 0) return;
  const int cellW = 6 * scale;
  const int baseTop = (cfg::MATRIX_H - 7 * scale) / 2;
  float strip = (float)len * cellW;
  for (uint8_t x = 0; x < cfg::MATRIX_W; x++) {
    float s = fmodf((float)x + scrollPx, strip);
    if (s < 0) s += strip;
    int idx = (int)(s / cellW);
    int col = (int)s - idx * cellW;
    if (col >= 5 * scale || idx >= len) continue;
    const uint8_t* gl = glyph(text[idx]);
    uint8_t bits = gl[col / scale];
    if (!bits) continue;
    CRGB c = color;
    if (rainbow) c = CHSV((uint8_t)(idx * 29 + (int)(t * 25.0f)), 235, 255);
    for (uint8_t row = 0; row < 7 * scale; row++) {
      if (bits & (1 << (row / scale))) {
        uint8_t px = flip ? (uint8_t)(cfg::MATRIX_W - 1 - x) : x;
        uint8_t py = (uint8_t)(flip ? (cfg::MATRIX_H - 1 - (baseTop + row)) : (baseTop + row));
        fb[XY(px, py)] = c;
      }
    }
  }
}

}  // namespace font5x7
